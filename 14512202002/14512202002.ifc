Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-07-09T10:59:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190731_1515(x64) - Exporter 20.1.1.1 - Alternate UI 20.1.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jul 09 10:59:39 2020 * Host: LT-GBA1 * Database: C:\Users\gba\AppData\Local\Temp\81390562-74b0-4fe5-81d8-6ebf5ad317fb\509709ad-43a5-4345-a391-c93e2a1b7a48\ifc * Database version: 5507 * Database creation date: Thu Jul 09 10:59:38 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jul 09 10:59:38 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jul 09 10:59:38 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 ft

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:1/4" Head, Level 1
LongName: Level 1; Elevation: 0 ft
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDoor: Dline_2PointLocking_PanicExitDevice_RightHanded, 14512202002:Dline_2PointLocking_PanicExitDevice_RightHanded:340333
In: Level 1
Type - ParameterTakesPrecedence: no; Sizeable: no
OverallHeight: 0.288714 ft; OverallWidth: 3.24311 ft
Pset_ConcreteElementGeneral - FireRating: n/a
Pset_DoorCommon - Reference: n/a; FireRating: n/a; AcousticRating: n/a; SecurityRating: n/a; IsExternal: no; GlazingAreaFraction: 0; HandicapAccessible: no; FireExit: no; SelfClosing: no; SmokeStop: no
Pset_ElementShading - Color: n/a
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: 45-25-60/365; Manufacturer: info@dline.com
Pset_PrecastConcreteElementGeneral - SerialNumber: n/a
Pset_ProductRequirements - Name: Dline_2PointLocking_PanicExitDevice_RightHanded; Category: Doors
Pset_QuantityTakeOff - Reference: n/a
